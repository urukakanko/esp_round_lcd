# Repository urukakanko/esp_round_lcd

## EAGLE design esp_round_lcd.brd

Parts:
C1, C2: 47p; C1608
C3, C5, C6: 10u; C1608
C4: 0.1u; C1608
CN1: U2CF16PA-2; U2CF16PA
D1: RB521S-30; SOD-523
J1: CONN_06SILK_FEMALE_PTH; 1X06
Q1, Q2, Q3: 200mA/50V; SOT23-3
R1, R6, R7, R8, R17: 1k; R0603
R2, R3: 4.7k; R0603
R4, R5: 27; R0603
R9: 2k; R0603
R10, R11, R12, R13, R18, R19, R20: 10k; R0603
R14, R15: 100; R0603
R16: N.C; R0603
S1, S2: TACT_SW_3X4; TACTILE_SWITCH_SMD_3X4MM
U1: AMS1117-3.3-SOT89; SOT-89
U2: CH340K; ESSOP10
U3: ESP-32SLM; ESP32D-SLM
U4: ROUND_IPS_LCD

Connections:
!DTR: Q1.2 (S), R7.2, R12.2
!RTS: Q2.2 (S), R9.1, R11.2, U2.6 (!RTS)
+3V3: C4.2, C5.1, C6.1, D1.A, R9.2, R10.1, R13.1, R18.1, R19.1, R20.1, U1.2 (OUT), U1.4 (OUT), U2.7 (VCC), U2.10 (V3), U3.2, U4.4 (VCC)
CC1: CN1.CC1, R3.2
CC2: CN1.CC2, R2.2
DM: C1.1, CN1.DN1 (D-), CN1.DN2 (D-), R4.1
DP: C2.1, CN1.DP1 (D+), CN1.DP2 (D+), R5.1
GND: C1.2, C2.2, C3.2, C4.1, C5.2, C6.2, CN1.GND, CN1.GND1 (GND), CN1.GND@9 (SHIELD), CN1.GND@10 (SHIELD), CN1.GND@11 (SHIELD), CN1.GND@12 (SHIELD), CN1.GND@13 (SHIELD), CN1.GND@14 (SHIELD), CN1.GND@15 (SHIELD), CN1.GND@16 (SHIELD), J1.1, Q3.2 (S), R1.1, R2.1, R3.1, S1.1, S1.2 (1), S2.1, S2.2 (1), U1.1 (GND), U2.3 (GND), U2.FGND, U2.FGND2 (FGND), U3.1, U3.15, U3.38, U3.GND (39), U3.GND2 (39), U4.1 (GND1), U4.5 (GND2), U4.6 (GND3), U4.12 (GND4)
IO0: Q1.3 (D), R10.2, S2.3 (2), S2.4 (2), U3.25
IO4: J1.3, U3.26
IO15: J1.2, U3.23
LCD_BL: R17.1, U3.13
LCD_CLK: U3.30, U4.9 (SCL)
LCD_CS: U3.29, U4.8 (CS)
LCD_DC: U3.8, U4.7 (D/C)
LCD_DI: R20.2, U3.37, U4.10 (SDA)
LCD_RESET: U3.9, U4.11 (RESET)
LED_K: R14.1, R15.1, R16.1, U4.2 (LEDK)
unnamed: Q3.1 (G), R17.2
unnamed: Q3.3 (D), R14.2, R15.2, R16.2
unnamed: R8.1, U2.9 (RXI)
unnamed: R6.1, U2.8 (TXO)
unnamed: Q2.1 (G), R12.1
unnamed: Q1.1 (G), R11.1
unnamed: R7.1, U2.4 (!DTR)
RESET: Q2.3 (D), R13.2, S1.3 (2), S1.4 (2), U3.3
RXD: R6.2, U3.34
SBU: CN1.SBU1 (SBU), CN1.SBU2 (SBU), R1.2
SCL: J1.5, R18.2, U3.36
SDA: J1.4, R19.2, U3.33
TXD: R8.2, U3.35
UDM: R4.2, U2.2 (UD-)
UDP: R5.2, U2.1 (UD+)
VBUS: C3.1, CN1.VBUS, CN1.VBUS1 (VBUS), D1.K (C), J1.6, U1.3 (IN), U4.3 (LEDA)

Notes on the sheet:
レギュレータ
USB入力
自動書き込み
ESP32
17-22 使えない

Board: 2 copper layers, 35.7 x 41.6 mm, 39 parts (2 on the bottom side), 34 nets.

Other parts of the board:
U$1: OSHIOKI

Notices in the files:
parts and their libraries:
SparkFun-DiscreteSemi: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
